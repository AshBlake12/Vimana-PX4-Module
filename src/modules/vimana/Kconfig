## src/modules/vimana/Kconfig
```kconfig
menuconfig MODULES_VIMANA
	bool "vimana"
	default n
	---help---
		Enable support for the Vimana custom VTOL module
```
